Commit message: Add .gitignore, and delete __pycache__ dirs

File: robolearn_envs/robot_models/hyq/hyq_lf_lh_rf_rh.urdf (robot description, URDF)
Before this commit: robot hyq, 13 links, 12 joints
Links:
- link trunk: mass 10.00 -> 58.96
